# Keil uVision project Panel57.uvprojx, settings and files
target Panel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelOSC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, DEBUG,PANEL
  c include: .\src;.\src\libs\CMSIS;.\src\libs\HAL;..\libs\common;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Panel57.sct
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
    ../common/libs/STM32Cube_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f429xx.h
  group libs/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_gpio.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_dma2d.h
    ./src/libs/HAL/: stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group common
    ../common/: Transceiver.cpp Transceiver.h Transceiver_Panel.cpp Command.h
  group src
    ./src/: main.cpp defines.h Log.cpp Log.h defines.cpp stdafx.h structs.h
  group Display
    ./src/Display/: Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h PainterText.cpp PainterSTM429.cpp Colors.cpp Colors.h Text.cpp Text.h Text_429.cpp Painter_common.h Averager.cpp Averager.h
  group Display/Font
    ../common/Display/Font/: Font.cpp Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc fontDigits64.cpp
  group Hardware
    ./src/Hardware/: CPU.cpp CPU.h CPU_IT.cpp Controls.h Keyboard.cpp Keyboard.h LTDC.cpp LTDC.h Timer.h
  group Hardware/stm32
    ./src/Hardware/stm32/: stm32.cpp stm32.h stm429.cpp stm429.h Timer4XX.cpp Timer4XX.h
  group Utils
    ./src/Utils/: DecoderPanel.cpp DecoderPanel.h Math.cpp Math.h Debug.cpp Debug.h
  group Settings
    ./src/Settings/: SettingsTypes.h Settings.h
