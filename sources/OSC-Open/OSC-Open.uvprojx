# Keil uVision project OSC-Open.uvprojx, settings and files
target OSC-Open (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: PanelOSC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F746xx, OPEN, DEBUG
  c include: .\src;.\src\libs\CMSIS;.\src\libs\HAL;..\Panel\src;..\common\libs\STM32Cube_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\common\libs\STM32Cube_F7\Drivers\STM32F7xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F7\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Panel/libs/CMSIS
    ./src/libs/CMSIS/: system_stm32f7xx.c startup_stm32f746xx.s
  group Panel/libs/HAL
    ./src/libs/HAL/: stm32f7xx_hal_conf.h
    ../common/libs/STM32Cube_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c
    ../common/libs/STM32Cube_F7/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h
  group Panel/src
    ../Panel/src/: defines.h Log.cpp Log.h
    ./src/: main.cpp Panel.h Panel.cpp
  group Panel/Display
    ../Panel/src/Display/: Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h PainterText.cpp PainterSTM429.cpp Colors.cpp Colors.h PainterTextSTM429.cpp
  group Panel/Display/font
    ../Panel/src/Display/font/: Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc Font.cpp
  group Panel/Hardware
    ../Panel/src/Hardware/: FSMC.cpp FSMC.h CPU_IT.cpp Controls.h
    ./src/Hardware/: CPU.cpp CPU.h Keyboard.cpp Keyboard.h LTDC.cpp LTDC.h
  group Panel/Hardware/stm32
    ./src/Hardware/stm32/: stm32.cpp stm32.h stm746.cpp stm746.h Timer7XX.cpp Timer7XX.h
  group Panel/Utils
    ../Panel/src/Utils/: Decoder.cpp Decoder.h Math.cpp Math.h
  group Panel/Settings
    ../Panel/src/Settings/: SettingsTypes.h Settings.h
