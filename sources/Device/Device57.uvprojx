# Keil uVision project Device57.uvprojx, settings and files
target Device (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S8-57 +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\S8-57.axf --output S8-57.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F437xx,DEVICE
  c include: .\src;.\src\Hardware\FatFS;.\src\Hardware\HAL;.\src\Hardware\USBD;.\src\Hardware\USBH;..\;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device.sct
  group common
    ../common/: Command.h Message.cpp Message.h Transceiver.cpp Transceiver.h Transceiver_Device.cpp
  group src
    ./src/: defines.h defines.cpp device.cpp device.h log.h log_stm.cpp main.cpp MessageMgr.h MessageMgr.cpp tables.h tables.cpp
  group Data
    ./src/Data/: DataSettings.cpp DataSettings.h Heap.cpp Heap.h Reader.cpp Reader.h
  group Display
    ./src/Display/: Colors.h Colors.cpp Console.h Console.cpp Display.h Display.cpp Grid.h Grid.cpp Painter.h Painter_stm.cpp PainterMem.h PainterMem.cpp Primitives.h Primitives.cpp Primitives_stm.cpp Symbols.h Warnings.h Warnings.cpp
  group Display/Font
    ../common/Display/Font/: Font.cpp Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc AdvancedFont.h AdvancedFont.cpp fontGOST72bold.inc fontGOST28.inc
  group FlashDrive
    ./src/FlashDrive/: FileManager.cpp FileManager.h FlashDrive.cpp FlashDrive.h
  group FPGA
    ./src/FPGA/: AD9286.h AD9286.cpp Calibrator.h Calibrator.cpp ContextFreqMeter.h ContextFreqMeter.cpp ContextRecorder.h ContextRecorder.cpp ContextTester.h ContextTester.cpp FPGA.h FPGA.cpp FPGA_HAL.cpp FPGA_HAL_stm.cpp FPGA_stm.cpp MathFPGA.h MathFPGA.cpp SettingsFPGA.cpp TypesFPGA.h
  group Hardware
    ./src/Hardware/: AT25160N.h AT25160N.cpp Battery.h Battery.cpp Beeper.h Beeper.cpp Timer.h Timer.cpp VCP.h VCP_stm.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f437xx.s system_stm32f4xx.c
  group Hardware/FatFS
    ./src/Hardware/FatFS/: ffconf.h
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h HAL.h HAL.cpp HAL_ADC1.cpp HAL_ADC3.cpp HAL_CRC32.cpp HAL_DAC1.cpp HAL_DAC2_stm.cpp HAL_FSMC_stm.cpp HAL_IT.cpp HAL_MSP.cpp HAL_NVIC.cpp HAL_OTP.cpp HAL_PIO.cpp HAL_PIO.h HAL_ROM_stm.cpp HAL_RTC.cpp HAL_TIM2_stm.cpp HAL_TIM3_stm.cpp HAL_USART3.cpp
  group Hardware/Memory
    ./src/Hardware/Memory/: RAM.h RAM.cpp ROM.h ROM.cpp ROM_Data.cpp Sector.h Sector.cpp
  group Hardware/USBD
    ./src/Hardware/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_core.cpp usbd_desc.cpp usbd_desc.h
  group Hardware/USBH
    ./src/Hardware/USBH/: usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group Keyboard
    ./src/Keyboard/: BufferButtons.cpp BufferButtons.h DecoderDevice.cpp DecoderDevice.h HandlersKeys.cpp HandlersKeys.h Keyboard.cpp Keyboard.h
  group Menu
    ./src/Menu/: Menu.h Menu.cpp MenuItems.h MenuItems.cpp MenuItemsDefs.h MenuItemsGraphics.cpp
  group Menu/Pages
    ./src/Menu/Pages/: PageChannels.cpp PageTime.cpp PageFFT.cpp PageFreqMeter.cpp PageFunction.cpp PageMultimeter.cpp PageTester.cpp
  group Menu/Pages/Include
    ./src/Menu/Pages/Include/: HelpContent.h HelpContentPages.h PageChannels.h PageDisplay.h PageFreqMeter.h PageFunction.h PageHelp.h PageMeasures.h PageMemory.h PageMultimeter.h PageRecorder.h PageService.h PageTester.h PageTime.h PageTrig.h DebugPage.h
  group Menu/Pages/PageDisplay
    ./src/Menu/Pages/PageDisplay/: PageDisplay.cpp PageDisplay_Settings.cpp PageDisplay_Settings_Colors.cpp PageAccumulation.cpp
  group Menu/Pages/PageHelp
    ./src/Menu/Pages/PageHelp/: HelpContent.cpp PageHelp.cpp
  group Menu/Pages/PageMeasures
    ./src/Menu/Pages/PageMeasures/: PageMeasures.cpp PageMeasures_Auto.cpp PageMeasures_Auto_Tune.cpp PageMeasures_Cursors.cpp PageMeasures_Cursors_Set.cpp PageMeasures_Math.cpp
  group Menu/Pages/PageMemory
    ./src/Menu/Pages/PageMemory/: PageMemory.cpp PageMemory_RAM.cpp PageMemory_ROM.cpp
  group Menu/Pages/PageRecorder
    ./src/Menu/Pages/PageRecorder/: PageRecorder.cpp PageRecorder_Show.cpp PageRecorder_Show_Choice.cpp PageRecorder_Show_Cursors.cpp PageRecorder_Source.cpp
  group Menu/Pages/PageService
    ./src/Menu/Pages/PageService/: PageService.cpp PageService_Battery.cpp PageService_Calibrate.cpp PageService_Info.cpp PageService_RTC.cpp
  group Menu/Pages/PageService/PageDebug
    ./src/Menu/Pages/PageService/PageDebug/: PageDebug.cpp PageDebug_Console.cpp PageDebug_Rand.cpp PageDebug_Tests.cpp PageDebug_ADC.cpp
  group Menu/Pages/PageTrig
    ./src/Menu/Pages/PageTrig/: PageTrig.cpp PageTrig_Find.cpp PageTrig_HoldOff.cpp
  group Multimeter
    ./src/Multimeter/: Multimeter.cpp Multimeter.h DisplayMultimeter.cpp
  group Osci
    ./src/Osci/: Osci.cpp Osci.h AveragerOsci.cpp SettingsOsci.cpp FreqMeter.cpp FreqMeter.h
  group Osci/Display
    ./src/Osci/Display/: Accumulator.cpp BottomPart.cpp DisplayOsci.h DisplayOsci.cpp HiPart.cpp MemoryWindow.cpp PainterData.cpp
  group Osci/Measurements
    ./src/Osci/Measurements/: AutoMeasurements.cpp AutoMeasurements.h AutoMeasurements_PageChoice.cpp AutoMeasurements_Table.cpp Measures.cpp Measures.h CursorsMeasurements.cpp CursorsMeasurements.h
  group Recorder
    ./src/Recorder/: Recorder.cpp Recorder.h DisplayRecorder.cpp DisplayRecorder.h StorageRecorder.cpp StorageRecorder.h
  group Settings
    ./src/Settings/: Settings.cpp Settings_stm.cpp Settings.h Settings_default.cpp SettingsOsci.h SettingsOsci.cpp
  group Test
    ./src/Test/: Test.cpp Test.h Test_Display.cpp Test_Memory.cpp
  group Tester
    ./src/Tester/: Tester.cpp Tester.h DisplayTester.cpp
  group Utils
    ./src/Utils/: Averager.cpp Averager.h Buffer.cpp Buffer.h CommonFunctions.cpp CommonFunctions.h Debug.cpp Debug.h Math.cpp Math.h Smoother.cpp Smoother.h Stack.cpp Stack.h String.cpp String.h StringUtils.cpp StringUtils.h tableslog.h TablesWindow.h Values.cpp Values.h Queue.cpp Queue.h
  group SCPI
    ./src/SCPI/: DisplaySCPI.cpp DisplaySCPI.h HeadSCPI.cpp HeadSCPI.h KeySCPI.cpp KeySCPI.h SCPI.cpp SCPI.h TBaseSCPI.cpp TBaseSCPI.h ChannelsSCPI.cpp ChannelsSCPI.h
  group ThirdParty/FatFS
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: ff.c ff.h diskio.c diskio.h ff_gen_drv.c ff_gen_drv.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
  group ThirdParty/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nor.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc_ex.c
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dma.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_nor.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_fmc.h stm32f4xx_ll_usb.h
  group ThirdParty/USBD
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_ctlreq.h usbd_ioreq.h usbd_core.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
  group ThirdParty/USBH
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_scsi.h usbh_msc_bot.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_ioreq.h usbh_pipes.h
