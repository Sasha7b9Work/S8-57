# Keil uVision project DeviceOSC.uvprojx, settings and files
target Device (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FPGA
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F437xx,OLD_RECORDER
  c include: .\src;.\src\libs\CMSIS;.\src\libs\HAL;..\libs\common;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\src\libs\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\src\libs\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common;.\src\libs\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device.sct
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f437xx.s system_stm32f4xx.c
  group libs/FatFS
    ./src/libs/FatFS/: ffconf.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: ff.c ff.h diskio.c diskio.h ff_gen_drv.c ff_gen_drv.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
  group libs/HAL
    ./src/libs/HAL/: stm32f4xx_hal_conf.h stm32f4xx_hal_msp.cpp
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nor.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dma.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_nor.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_fmc.h stm32f4xx_ll_usb.h
  group libs/USBD
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_ctlreq.h usbd_ioreq.h usbd_core.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
    ./src/libs/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_core.cpp usbd_desc.cpp usbd_desc.h
  group libs/USBH
    ./src/libs/USBH/: usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_scsi.h usbh_msc_bot.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_ioreq.h usbh_pipes.h
  group common
    ../common/: Command.h Message.cpp Message.h
  group src
    ./src/: defines.h main.cpp main.h defines.cpp device.cpp device.h log.cpp log.h tables.cpp tables.h
  group Data
    ./src/Data/: DataBuffer.cpp DataBuffer.h DataSettings.cpp DataSettings.h DataStorage.cpp DataStorage.h Heap.cpp Heap.h Reader.cpp Reader.h
  group Display
    ./src/Display/: Colors.cpp Colors.h Console.cpp Console.h Display.cpp Display.h Display_Types.h Display_Primitives.cpp Display_Primitives.h Display_Warnings.h Painter_437.cpp Painter.h PainterMem.cpp PainterMem.h Symbols.h Grid.cpp Grid.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc
  group FlashDrive
    ./src/FlashDrive/: FileManager.cpp FileManager.h FlashDrive.cpp FlashDrive.h
  group FPGA
    ./src/FPGA/: AD9286.cpp AD9286.h FPGA.cpp FPGA.h FPGA_437.cpp FPGA_HAL.cpp FPGA_HAL.h FPGA_Math.cpp FPGA_Math.h FPGA_Settings.cpp FPGA_Settings.h FPGA_Types.cpp FPGA_Types.h
  group Hardware
    ./src/Hardware/: AT25160N.cpp AT25160N.h CPU.cpp CPU.h CPU_IT.cpp EEPROM.cpp EEPROM.h EEPROM_437.cpp FSMC.cpp FSMC.h FSMC_437.cpp GPIO.cpp GPIO.h Hardware.cpp Hardware.h Timer.cpp Timer.h Timer_437.cpp Sound.cpp Sound.h VCP.cpp VCP.h
  group Hardware/stm32
    ./src/Hardware/stm32/: stm32.cpp stm32.h stm437.cpp stm437.h Timer4XX.cpp Timer4XX.h
  group Keyboard
    ./src/Keyboard/: DecoderDevice.cpp DecoderDevice.h Keyboard.cpp Keyboard.h
  group Menu
    ./src/Menu/: BufferButtons.h BufferButtons.cpp HandlersKeys.h HandlersKeys.cpp Menu.h Menu.cpp MenuItems.h MenuItems.cpp MenuItemsAdd.h MenuItemsDefs.h MenuItemsGraphics.cpp MenuItemsLogic.cpp MenuTriggers.h MenuTriggers.cpp
  group Menu/Pages
    ./src/Menu/Pages/: Definition.cpp PageChannels.cpp PageTime.cpp
  group Menu/Pages/Include
    ./src/Menu/Pages/Include/: Definition.h HelpContent.h HelpContentPages.h PageChannels.h PageDebug.h PageDisplay.h PageFunction.h PageHelp.h PageMeasures.h PageMemory.h PageService.h PageTime.h PageTrig.h
  group Menu/Pages/PageDebug
    ./src/Menu/Pages/PageDebug/: PageDebug.cpp PageDebug_Console.cpp PageDebug_Rand.cpp
  group Menu/Pages/PageDisplay
    ./src/Menu/Pages/PageDisplay/: PageDisplay.cpp PageDisplay_Accumulation.cpp PageDisplay_Average.cpp PageDisplay_Grid.cpp PageDisplay_Settings.cpp PageDisplay_Settings_Colors.cpp
  group Menu/Pages/PageFunction
    ./src/Menu/Pages/PageFunction/: PageFunction.cpp PageFunction_FFT.cpp PageFunction_FrequencyCounter.cpp PageFunction_Multimeter.cpp PageFunction_Tester.cpp
  group Menu/Pages/PageFunction/PageRecorder
    ./src/Menu/Pages/PageFunction/PageRecorder/: PageRecorder.cpp PageRecorder_Record.cpp PageRecorder_Show.cpp PageRecorder_Show_Operations.cpp PageRecorder_Show_View.cpp PageRecorder_Show_View_Cursors.cpp PageRecorder_Source.cpp
  group Menu/Pages/PageHelp
    ./src/Menu/Pages/PageHelp/: HelpContent.cpp PageHelp.cpp
  group Menu/Pages/PageMeasures
    ./src/Menu/Pages/PageMeasures/: PageMeasures.cpp PageMeasures_Auto.cpp PageMeasures_Auto_Tune.cpp PageMeasures_Cursors.cpp PageMeasures_Cursors_Set.cpp
  group Menu/Pages/PageMemory
    ./src/Menu/Pages/PageMemory/: PageMemory.cpp PageMemory_RAM.cpp PageMemory_ROM.cpp
  group Menu/Pages/PageService
    ./src/Menu/Pages/PageService/: PageService.cpp
  group Menu/Pages/PageTrig
    ./src/Menu/Pages/PageTrig/: PageTrig.cpp PageTrig_HoldOff.cpp
  group Multimeter
    ./src/Multimeter/: Multimeter.cpp Multimeter.h Multimeter_Display.cpp
  group Osci
    ./src/Osci/: Cursors.cpp Cursors.h FrequencyCounter.cpp FrequencyCounter.h Osci.cpp Osci.h Osci_Display.cpp Osci_Display.h Osci_Settings.cpp Osci_Settings.h
  group Osci/Display
    ./src/Osci/Display/: BottomPart.cpp BottomPart.h HiPart.cpp HiPart.h MemoryWindow.cpp MemoryWindow.h PainterData.cpp PainterData.h
  group Recorder
    ./src/Recorder/: Recorder.cpp Recorder.h Recorder_Display.cpp Recorder_Display.h Recorder_Settings.cpp Recorder_Settings.h Recorder_Storage.cpp Recorder_Storage.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h Settings_default.cpp SettingsChannel.cpp SettingsChannel.h SettingsDebug.cpp SettingsDebug.h SettingsMath.h SettingsMemory.cpp SettingsMemory.h SettingsNRST.h SettingsService.h SettingsTime.h SettingsTransformation.cpp
  group Tester
    ./src/Tester/: Tester.cpp Tester.h TesterGraphics.cpp
  group Utils
    ./src/Utils/: Buffer.cpp Buffer.h CommonFunctions.cpp CommonFunctions.h Debug.cpp Debug.h Dictionary.cpp Dictionary.h Math.cpp Math.h Measure.cpp Measure.h MeasureProcessing.cpp Stack.cpp Stack.h String.cpp String.h StringUtils.cpp StringUtils.h tableslog.h TablesWindow.h Values.cpp Values.h
  group SCPI
    ./src/SCPI/: SCPI.cpp SCPI.h
